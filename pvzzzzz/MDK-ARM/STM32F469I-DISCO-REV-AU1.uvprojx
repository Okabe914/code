# Keil uVision project STM32F469I-DISCO-REV-AU1.uvprojx, settings and files
target STM32F469I-DISCO-REV-AU1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F469NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2004FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32F469I-DISCO-REV-AU1 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F469xx,USE_BPP=16
  c include: ../Core/Inc;../TouchGFX/App;../TouchGFX/target/generated;../TouchGFX/target;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Drivers/BSP/Components/Common;../Drivers/BSP/STM32469I-Discovery;../middlewares/st/touchgfx/framework/include;../touchgfx/generated/fonts/include;../touchgfx/generated/gui_generated/include;../touchgfx/generated/images/include;../touchgfx/generated/texts/include;../touchgfx/generated/videos/include;../touchgfx/gui/include
  asm include: ..\Core\Inc;../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\STM32F469I-DISCO-REV-AU1.sct
  group Application/MDK-ARM
    ./: startup_stm32f469xx.s
  group Application/User/TouchGFX/target
    ../TouchGFX/target/: CortexMMCUInstrumentation.cpp Buttons.cpp KeySampler.cpp TouchGFXHAL.cpp STM32TouchController.cpp TouchGFXGPIO.cpp
  group Application/User/TouchGFX/target/generated
    ../TouchGFX/target/generated/: TouchGFXConfiguration.cpp TouchGFXGeneratedHAL.cpp STM32DMA.cpp OSWrappers.cpp
  group Application/User/TouchGFX/App
    ../TouchGFX/App/: app_touchgfx.c
  group Application/User/Core
    ../Core/Src/: main.c freertos.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/nt35510/: nt35510.c
    ../Drivers/BSP/Components/ft6x06/: ft6x06.c
  group Drivers/BSP/STM32469I-Discovery
    ../Drivers/BSP/STM32469I-Discovery/: stm32469i_discovery.c stm32469i_discovery_qspi.c stm32469i_discovery_sdram.c stm32469i_discovery_ts.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_crc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dsi.c stm32f4xx_ll_fmc.c stm32f4xx_hal_sdram.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group gui
    ../touchgfx/gui/src/backyard_screen/: backyardpresenter.cpp backyardview.cpp
    ../touchgfx/gui/src/containers/: bullet.cpp car.cpp plant.cpp zombie.cpp
    ../touchgfx/gui/src/common/: frontendapplication.cpp
    ../touchgfx/gui/src/menu_screen/: menupresenter.cpp menuview.cpp
    ../touchgfx/gui/src/model/: model.cpp
    ../touchgfx/gui/src/screenwin_screen/: screenwinpresenter.cpp screenwinview.cpp
  group Lib
    ../middlewares/st/touchgfx/lib/core/cortex_m4f/Keil/: touchgfx_core.lib
  group generated
    ../touchgfx/generated/fonts/src/: applicationfontprovider.cpp cachedfont.cpp font_rockeb_ttf_20_4bpp_0.cpp font_rockeb_ttf_24_4bpp_0.cpp font_rockeb_ttf_40_4bpp_0.cpp font_rockeb_ttf_50_4bpp_0.cpp font_simkai_20_4bpp_0.cpp font_simkai_20_4bpp_10.cpp font_simkai_20_4bpp_11.cpp font_simkai_20_4bpp_18.cpp font_simkai_20_4bpp_19.cpp font_verdana_10_4bpp_0.cpp font_verdana_40_4bpp_0.cpp fontcache.cpp generatedfont.cpp kerning_rockeb_ttf_20_4bpp.cpp kerning_rockeb_ttf_24_4bpp.cpp kerning_rockeb_ttf_40_4bpp.cpp kerning_rockeb_ttf_50_4bpp.cpp kerning_simkai_20_4bpp.cpp kerning_verdana_10_4bpp.cpp kerning_verdana_40_4bpp.cpp table_rockeb_ttf_20_4bpp.cpp table_rockeb_ttf_24_4bpp.cpp table_rockeb_ttf_40_4bpp.cpp table_rockeb_ttf_50_4bpp.cpp table_simkai_20_4bpp.cpp table_verdana_10_4bpp.cpp table_verdana_40_4bpp.cpp unmappeddatafont.cpp
    ../touchgfx/generated/gui_generated/src/backyard_screen/: backyardviewbase.cpp
    ../touchgfx/generated/images/src/: bitmapdatabase.cpp image_almanac_zombiewindow.cpp image_almanac_zombiewindow2.cpp image_alpha.cpp image_awardscreen_back.cpp image_bar5.cpp image_btnclosedown.cpp image_btnclosenormal.cpp image_car1.cpp image_flagmeter1.cpp image_flagmeter2.cpp image_flagmeterlevelprogress.cpp image_flagmeterparts.cpp image_help.cpp image_map01.cpp image_map02.cpp image_menu1.cpp image_menu2.cpp image_menu_resized.cpp image_options_backtogamebutton0.cpp image_optionsmenuback32.cpp image_pause.cpp image_peanormal_0.cpp image_rail.cpp image_shovel_resized.cpp image_shovelslot_resized.cpp image_surface_resized.cpp image_trophy.cpp image_zombatar_back_button.cpp image_zombatar_back_button_highlight.cpp image_zombienotehelp.cpp image_zombieswon.cpp svgdatabase.cpp
    ../touchgfx/generated/gui_generated/src/containers/: bulletbase.cpp carbase.cpp plantbase.cpp zombiebase.cpp
    ../touchgfx/generated/gui_generated/src/common/: frontendapplicationbase.cpp
    ../touchgfx/generated/images/src/__generated/: image_alternate_theme_images_widgets_button_regular_height_50_medium_rounded_normal.cpp image_alternate_theme_images_widgets_button_regular_height_50_medium_rounded_pressed.cpp
    ../touchgfx/generated/images/src/plant/: image_peashooter_a.cpp image_peashooter_b.cpp image_peashooter_c.cpp image_peashooter_d.cpp image_peashooter_e.cpp image_peashooter_f.cpp image_peashooter_g.cpp image_peashooter_h.cpp image_peashooter_i.cpp image_peashooter_j.cpp image_peashooter_k.cpp image_peashooter_l.cpp image_peashooter_m.cpp
    ../touchgfx/generated/images/src/zombie_walkimages/: image_zombie_walk_a.cpp image_zombie_walk_b.cpp image_zombie_walk_c.cpp image_zombie_walk_d.cpp image_zombie_walk_e.cpp image_zombie_walk_f.cpp image_zombie_walk_g.cpp image_zombie_walk_h.cpp image_zombie_walk_i.cpp image_zombie_walk_j.cpp image_zombie_walk_k.cpp image_zombie_walk_l.cpp image_zombie_walk_m.cpp image_zombie_walk_n.cpp image_zombie_walk_o.cpp image_zombie_walk_p.cpp image_zombie_walk_q.cpp
    ../touchgfx/generated/texts/src/: languagegb.cpp texts.cpp typedtextdatabase.cpp
    ../touchgfx/generated/gui_generated/src/menu_screen/: menuviewbase.cpp
    ../touchgfx/generated/gui_generated/src/screenwin_screen/: screenwinviewbase.cpp
software components: CMSIS:CORE 4.3.0
